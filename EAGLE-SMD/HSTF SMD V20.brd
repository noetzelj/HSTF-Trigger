# Repository noetzelj/HSTF-Trigger

File README.md:

# HSTF-Trigger
Long Range Camera Trigger with DTMF Addressing

Holy Shit That's Far (HSTF) Trigger

Very long range camera trigger with optional voice reporting talkback.  Uses an Arduino, a few other components, and a Baoefeng UV-5R.

## EAGLE design EAGLE-SMD/HSTF SMD V20.brd

Parts:
CAMERA_JACK: STEREOJACK; STX3100
DTMF_AUDIO: CONN_021X02_NO_SILK; 1X02_NO_SILK
DTMF_MODULE: CONN_09NO_SILK; 1X09_NO_SILK
FOCUS_SW: CONN_021X02_NO_SILK; 1X02_NO_SILK
LEFT_TRINKET: CONN_12NO_SILK; 1X12_NO_SILK
OPTO_PTT_VOICE: VOD205T; SOIC127P610X331-8N
OPTO_TRIGGER: VOD205T; SOIC127P610X331-8N
R1, R2, R3: 220; 0805
R4: 2.2K; 0805
RADIO: CONN_04LONGPADS; 1X04_LONGPADS
RIGHT_TRINKET: CONN_12NO_SILK; 1X12_NO_SILK
R_BAT+: CONN_01; 1X01
R_BAT-: CONN_01; 1X01
STRAIN, STRAIN1: CONN_01; 1X01

Connections:
BAT+: RIGHT_TRINKET.12, R_BAT+.1
CAM_COMMON: CAMERA_JACK.1, OPTO_TRIGGER.8 (CO2)
FIRE: R3.1, RIGHT_TRINKET.8
FOCUS: CAMERA_JACK.5, FOCUS_SW.2
GND: DTMF_MODULE.1, OPTO_PTT_VOICE.2 (C1), OPTO_PTT_VOICE.4 (C2), OPTO_TRIGGER.2 (C1), RIGHT_TRINKET.11, R_BAT-.1
MIC+: R4.2, RADIO.2
MIC-: OPTO_PTT_VOICE.6 (CO1), OPTO_PTT_VOICE.8 (CO2), RADIO.4
unnamed: OPTO_PTT_VOICE.1 (A1), R1.2
unnamed: OPTO_PTT_VOICE.3 (A2), R2.2
unnamed: OPTO_PTT_VOICE.5 (E1), R4.1
unnamed: OPTO_TRIGGER.1 (A1), R3.2
PTT: R1.1, RIGHT_TRINKET.5
Q1: DTMF_MODULE.9, LEFT_TRINKET.1
Q2: DTMF_MODULE.8, LEFT_TRINKET.2
Q3: DTMF_MODULE.7, LEFT_TRINKET.3
Q4: DTMF_MODULE.6, LEFT_TRINKET.4
SHUTTER: CAMERA_JACK.3, FOCUS_SW.1, OPTO_TRIGGER.7 (E2)
SPK+: DTMF_AUDIO.2, RADIO.1
SPK-: DTMF_AUDIO.1, OPTO_PTT_VOICE.7 (E2), RADIO.3
ST_Q: DTMF_MODULE.5, LEFT_TRINKET.5
VBUS: DTMF_MODULE.2, RIGHT_TRINKET.10
VOICE: R2.1, RIGHT_TRINKET.4

Board: 2 copper layers, 34.3 x 43.8 mm, 17 parts (0 on the bottom side), 22 nets.

## EAGLE design EAGLE/HSTF 2018 - Eagle - V01.brd

Parts:
BAT+: CONN_01PTH_2MM; 1X01_2MM
BAT-: CONN_01PTH_2MM; 1X01_2MM
CAMERA_CABLE: STEREOJACK; STX3100
DTMF_AUDIO_IN: Female; 1X02
DTMF_MODULE: Female; 1X09
FOCUS_SW: Female; 1X02
H1: STAND-OFFTIGHT; STAND-OFF-TIGHT
H2: STAND-OFF
PTT: PC817; DIL04
R1, R2, R3: 220; 0207/10
R4: 2.2K; 0207/10
RADIO: Female; 1X04
STRAIN, STRAIN1: CONN_01PTH_2MM; 1X01_2MM
TRIGGER: PC817; DIL04
VOICE: PC817; DIL04

Connections:
COMMON: CAMERA_CABLE.1, TRIGGER.4 (COL)
FOCUS: CAMERA_CABLE.5, FOCUS_SW.1
GND: BAT-.1, DTMF_MODULE.9, PTT.2 (C), TRIGGER.2 (C), VOICE.2 (C); also elsewhere on the board
MIC+: R4.1, RADIO.2
MIC-: PTT.4 (COL), RADIO.4, VOICE.4 (COL)
unnamed: R3.2, VOICE.1 (A)
unnamed: PTT.1 (A), R2.2
unnamed: R4.2, VOICE.3 (EMIT)
OOPS: R1.2, TRIGGER.1 (A)
PTT: R2.1; also elsewhere on the board
Q1: DTMF_MODULE.1; also elsewhere on the board
Q2: DTMF_MODULE.2; also elsewhere on the board
Q3: DTMF_MODULE.3; also elsewhere on the board
Q4: DTMF_MODULE.4; also elsewhere on the board
SP+: DTMF_AUDIO_IN.1, RADIO.1
SP-: DTMF_AUDIO_IN.2, PTT.3 (EMIT), RADIO.3
ST_Q: DTMF_MODULE.5; also elsewhere on the board
TRIGGER: CAMERA_CABLE.2, FOCUS_SW.2, TRIGGER.3 (EMIT)
TRIGGER_CTL: R1.1; also elsewhere on the board
V+: BAT+.1; also elsewhere on the board
VBUS: DTMF_MODULE.8; also elsewhere on the board
VOICE: R3.1; also elsewhere on the board

Notes on the sheet:
Jim Noetzel jim@noetzel.net
HSTF V01.5 Jim@ Noetzel.net

Parts:
LEFT: PINHD-1X12; 1X12
RIGHT: PINHD-1X12; 1X12

Connections:
5: RIGHT.7
6: RIGHT.6
GND: RIGHT.2; also elsewhere on the board
PTT: RIGHT.8; also elsewhere on the board
Q1: LEFT.1; also elsewhere on the board
Q2: LEFT.2; also elsewhere on the board
Q3: LEFT.3; also elsewhere on the board
Q4: LEFT.4; also elsewhere on the board
ST_Q: LEFT.5; also elsewhere on the board
TRIGGER_CTL: RIGHT.5; also elsewhere on the board
V+: RIGHT.1; also elsewhere on the board
VBUS: RIGHT.3; also elsewhere on the board
VCC: RIGHT.4
VOICE: RIGHT.9; also elsewhere on the board

Board: 2 copper layers, 43.2 x 45.7 mm, 18 parts (0 on the bottom side), 22 nets.

## Commit log

2017-11-13 Create Morse - from online
2017-11-13 Update Morse - from online
2018-01-21 Add files via upload
    Yeah, it's messy....it's the initial upload.

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
